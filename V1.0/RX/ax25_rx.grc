options:
  parameters:
    generate_options: qt_gui
    id: ax25_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '200000000'
    value: '200000'
  states: {}
- name: Center_Freq
  id: variable_qtgui_range
  parameters:
    start: '88000000'
    step: '1'
    stop: 108e6
    value: 91e6
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 48e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/akiboy/Akiboy-MegaHertz/AX.25_Telemetry_Protocol/received.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: BW
    center_freq0: Center_Freq
    gain0: '100'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
